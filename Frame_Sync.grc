options:
  parameters:
    author: Xiangyu Zhang
    description: frame syncing
    generate_options: qt_gui
    id: frame_sync
    output_language: python
    title: Frame Sync
  states: {}

blocks:
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"# of bits"'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '9'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.7'
    comment: |-
      A = 0.69   correlation threshold can be 0
      A = 0.7 threshould need to be 1
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Display the message that was sent.
  states: {}
- name: blocks_message_strobe_0_0_0_0
  id: blocks_message_strobe
  parameters:
    comment: Generate data ("Beyond 5G")
    msg: pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(numpy.array([ord(c) for c in "Beyond 5G"], numpy.uint8)))
    period: '1000'
  states: {}
- name: blocks_pdu_to_tagged_stream_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: length_tag_key
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: length_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: header_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_0_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: header_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {state: disabled}
- name: blocks_repack_bits_bb_0_0_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: header_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {state: disabled}
- name: blocks_repack_bits_bb_0_0_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: header_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    comment: Simulate the channel
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: Append header to payload
    lengthtagname: length_tag_key
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: length_tag_key
    type: byte
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0_0_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0_0_0_0_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: |-
      To display in time domain we map individual 
      bits to (complex) symbols
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0_0_0_0_0_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0_0_0_0_0_0_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {}
- name: digital_correlate_access_code_xx_ts_1
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    comment: Correlates with preamble to extract the payload.
    tagname: length_tag_key
    threshold: '1'
    type: byte
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: Generate CRC
    lengthtagname: length_tag_key
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: length_tag_key
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    comment: Generate preamble
    format: header_format
    len_tag_key: length_tag_key
  states: {}
- name: header_format
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: dark blue
    gui_hint: (1,3,1,3)
    label1: ''
    label2: ''
    legend: 'False'
    name: Frame before transmittion (Preamble + Data + CRC32)
    size: '300'
    srate: samp_rate
    style2: '0'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: dark blue
    comment: Display payloud in time domain
    gui_hint: (1,0,1,3)
    label1: ''
    label2: ''
    legend: 'False'
    name: Data + CRC32
    size: '200'
    srate: samp_rate
    style2: '0'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: dark green
    comment: Display payloud in time domain
    gui_hint: (3,0,1,3)
    label1: ''
    label2: ''
    legend: 'False'
    name: Recover the original data (- CRC)
    size: '200'
    srate: samp_rate
    style2: '0'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: dark green
    comment: Display payloud in time domain
    gui_hint: (2,3,1,3)
    label1: ''
    label2: ''
    legend: 'False'
    name: Find the start of the data (- preamble)
    size: '200'
    srate: samp_rate
    style2: '0'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: dark blue
    gui_hint: (0,3,1,3)
    label1: ''
    label2: ''
    legend: 'False'
    name: Preamble
    size: '200'
    srate: samp_rate
    style2: '0'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    color1: dark blue
    comment: Display payloud in time domain
    gui_hint: 0,0,1,3
    label1: ''
    label2: ''
    legend: 'False'
    name: Data ("Beyond 5G")
    size: '200'
    srate: samp_rate
    style2: '0'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_0_1
  id: qtgui_time_sink_x
  parameters:
    color1: dark red
    gui_hint: (2,0,1,3)
    label1: ''
    label2: ''
    legend: 'False'
    name: Frame after transmittion
    size: '300'
    srate: samp_rate
    style2: '0'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Transmitted
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Received
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Transmitted
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Received
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_tag_gate_0_0, '0']
- [blocks_message_strobe_0_0_0_0, strobe, blocks_pdu_to_tagged_stream_1, pdus]
- [blocks_pdu_to_tagged_stream_1, '0', blocks_repack_bits_bb_0_0_1_0_0_0, '0']
- [blocks_pdu_to_tagged_stream_1, '0', digital_crc32_bb_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_repack_bits_bb_0_0_1, '0', digital_chunks_to_symbols_xx_0_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_1_0, '0', digital_chunks_to_symbols_xx_0_0_0_0_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_1_0_0, '0', digital_chunks_to_symbols_xx_0_0_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_1_0_0_0, '0', digital_chunks_to_symbols_xx_0_0_0_0_0_0_1, '0']
- [blocks_tag_gate_0_0, '0', qtgui_time_sink_x_0_1_0_0_1, '0']
- [blocks_tag_gate_0_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_0_0_1, '0']
- [blocks_tagged_stream_mux_0, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [digital_chunks_to_symbols_xx_0_0_0_0_0, '0', qtgui_time_sink_x_0_1_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0_0_0, '0', virtual_sink_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_1_0_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_1_0_0_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0_0_0_0_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_1_0_0_0_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0_0_0_0_1, '0', qtgui_time_sink_x_0_1_0_0_0_0_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_correlate_access_code_xx_ts_1, '0']
- [digital_correlate_access_code_xx_ts_1, '0', blocks_repack_bits_bb_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_1, '0', digital_chunks_to_symbols_xx_0_0_0_0_0_0_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_repack_bits_bb_0_0_1_0_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_repack_bits_bb_0_0_1_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '0']
- [virtual_source_0_0, '0', digital_constellation_decoder_cb_0, '0']

metadata:
  file_format: 1
